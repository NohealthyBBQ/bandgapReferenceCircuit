v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1130 -340 1260 -340 { lab=Vb}
N 670 -50 670 -20 { lab=GND}
N 610 -80 670 -80 { lab=GND}
N 610 -80 610 -20 { lab=GND}
N 670 -680 890 -680 { lab=VDD}
N 1130 -680 1330 -680 { lab=VDD}
N 1130 -340 1130 -320 { lab=Vb}
N 1130 -420 1130 -340 { lab=Vb}
N 1640 -470 1640 -340 { lab=vbg}
N 1130 -260 1130 -240 { lab=#net1}
N 1260 -340 1260 -320 { lab=Vb}
N 1260 -260 1260 -240 { lab=#net2}
N 540 -340 540 -320 { lab=Va}
N 540 -260 540 -240 { lab=#net3}
N 1130 -550 1130 -480 { lab=#net4}
N 1130 -180 1130 -110 { lab=vbneg}
N 540 -160 540 -20 { lab=GND}
N 1260 -150 1260 -20 { lab=GND}
N 1640 -260 1640 -20 { lab=GND}
N 1170 -80 1170 -20 { lab=GND}
N 1130 -50 1130 -20 { lab=GND}
N 1090 -80 1130 -80 { lab=GND}
N 1090 -80 1090 -20 { lab=GND}
N 710 -80 730 -80 { lab=GND}
N 730 -80 730 -20 { lab=GND}
N 520 -210 520 -160 { lab=GND}
N 520 -160 540 -160 { lab=GND}
N 1240 -210 1240 -150 { lab=GND}
N 1240 -150 1260 -150 { lab=GND}
N 1030 -210 1110 -210 { lab=GND}
N 1030 -210 1030 -20 { lab=GND}
N 1620 -310 1620 -260 { lab=GND}
N 1620 -260 1640 -260 { lab=GND}
N 670 -260 670 -110 { lab=Veb}
N 1020 -340 1130 -340 { lab=Vb}
N 150 -50 160 -50 { lab=GND}
N 150 -50 150 -20 { lab=GND}
N 200 -50 330 -50 { lab=Vx}
N 370 -50 380 -50 { lab=GND}
N 330 -80 330 -50 { lab=Vx}
N 330 -80 370 -80 { lab=Vx}
N 380 -50 380 -20 { lab=GND}
N 1520 -680 1640 -680 { lab=VDD}
N 1130 -680 1130 -610 { lab=VDD}
N 1640 -590 1650 -590 { lab=VDD}
N 1650 -620 1650 -590 { lab=VDD}
N 1640 -620 1650 -620 { lab=VDD}
N 1520 -20 1640 -20 { lab=GND}
N 670 -340 670 -320 { lab=Va}
N 1090 -590 1090 -580 { lab=vgate}
N 630 -590 630 -580 { lab=vgate}
N 670 -550 670 -490 { lab=#net5}
N 370 -580 380 -580 { lab=VDD}
N 380 -610 380 -580 { lab=VDD}
N 370 -610 380 -610 { lab=VDD}
N 670 -580 680 -580 { lab=VDD}
N 680 -610 680 -580 { lab=VDD}
N 670 -610 680 -610 { lab=VDD}
N 670 -680 670 -610 { lab=VDD}
N 1130 -580 1140 -580 { lab=VDD}
N 1140 -610 1140 -580 { lab=VDD}
N 1130 -610 1140 -610 { lab=VDD}
N 160 -470 160 -80 { lab=Vq}
N 410 -680 670 -680 { lab=VDD}
N 1570 -590 1600 -590 { lab=vgate}
N 330 -590 330 -580 { lab=vgate}
N 370 -680 370 -610 { lab=VDD}
N 370 -360 370 -80 { lab=Vx}
N 670 -340 740 -340 { lab=Va}
N 540 -340 670 -340 { lab=Va}
N 1640 -680 1640 -620 { lab=VDD}
N 1640 -560 1640 -530 { lab=#net6}
N 610 -20 670 -20 { lab=GND}
N 540 -20 610 -20 { lab=GND}
N 420 -20 540 -20 { lab=GND}
N 1170 -20 1260 -20 { lab=GND}
N 1130 -20 1170 -20 { lab=GND}
N 1090 -20 1130 -20 { lab=GND}
N 1030 -20 1090 -20 { lab=GND}
N 670 -20 730 -20 { lab=GND}
N 540 -180 540 -160 { lab=GND}
N 1260 -180 1260 -150 { lab=GND}
N 730 -20 790 -20 { lab=GND}
N 1640 -280 1640 -260 { lab=GND}
N 150 -20 380 -20 { lab=GND}
N 1330 -680 1520 -680 { lab=VDD}
N 370 -550 370 -360 { lab=Vx}
N 630 -590 850 -590 { lab=vgate}
N 850 -590 1330 -590 { lab=vgate}
N 670 -430 670 -340 { lab=Va}
N 370 -680 410 -680 { lab=VDD}
N 380 -20 420 -20 { lab=GND}
N 470 -590 630 -590 { lab=vgate}
N 330 -590 470 -590 { lab=vgate}
N 1460 -480 1460 -20 { lab=GND}
N 1460 -510 1470 -510 { lab=GND}
N 1460 -480 1470 -510 { lab=GND}
N 1460 -590 1460 -540 { lab=vgate}
N 460 -340 460 -310 { lab=Va}
N 1370 -680 1370 -660 { lab=VDD}
N 1370 -600 1370 -590 { lab=vgate}
N 460 -250 460 -20 { lab=GND}
N 460 -340 540 -340 { lab=Va}
N 1640 -680 1940 -680 {
lab=VDD}
N 1940 -680 1970 -680 {
lab=VDD}
N 1940 -680 1940 -510 {
lab=VDD}
N 1970 -680 1970 -510 {
lab=VDD}
N 1810 -450 1870 -450 {
lab=vfeedback}
N 2040 -430 2090 -430 {
lab=vcurrent_gate}
N 2090 -430 2150 -430 {
lab=vcurrent_gate}
N 1970 -680 2190 -680 {
lab=VDD}
N 1810 -450 1810 -290 {
lab=vfeedback}
N 1810 -290 2190 -290 {
lab=vfeedback}
N 1970 -370 1970 -330 {
lab=GND}
N 2190 -290 2190 -210 {
lab=vfeedback}
N 2190 -150 2190 -20 {
lab=GND}
N 1640 -20 2190 -20 {
lab=GND}
N 2190 -400 2190 -380 {
lab=vd4}
N 2190 -320 2190 -290 {
lab=vfeedback}
N 2130 -180 2170 -180 {
lab=GND}
N 2130 -180 2130 -90 {
lab=GND}
N 2130 -90 2190 -90 {
lab=GND}
N 1640 -410 1870 -410 {
lab=vbg}
N 2190 -450 2190 -400 {
lab=vd4}
N 2130 -480 2130 -430 {
lab=vcurrent_gate}
N 2130 -480 2150 -480 {
lab=vcurrent_gate}
N 2190 -680 2190 -510 {
lab=VDD}
N 2370 -400 2370 -380 {
lab=vd5}
N 2370 -450 2370 -400 {
lab=vd5}
N 2310 -480 2310 -430 {
lab=vcurrent_gate}
N 2310 -480 2330 -480 {
lab=vcurrent_gate}
N 2150 -430 2310 -430 {
lab=vcurrent_gate}
N 2370 -680 2370 -510 {
lab=VDD}
N 2190 -680 2370 -680 {
lab=VDD}
N 2370 -40 2370 -20 {
lab=GND}
N 2190 -20 2370 -20 {
lab=GND}
N 2370 -130 2370 -100 {
lab=#net7}
N 2320 -160 2320 -20 {
lab=GND}
N 2320 -70 2370 -70 {
lab=GND}
N 2190 -480 2240 -480 {
lab=VDD}
N 2240 -530 2240 -480 {
lab=VDD}
N 2190 -530 2240 -530 {
lab=VDD}
N 2370 -480 2430 -480 {
lab=VDD}
N 2430 -530 2430 -480 {
lab=VDD}
N 2370 -530 2430 -530 {
lab=VDD}
N 2370 -320 2370 -290 {
lab=#net7}
N 2410 -70 2450 -70 {
lab=#net7}
N 2320 -260 2350 -260 {
lab=GND}
N 2320 -260 2320 -160 {
lab=GND}
N 920 -340 1020 -340 {
lab=Vb}
N 920 -370 920 -340 {
lab=Vb}
N 740 -340 880 -340 {
lab=Va}
N 880 -370 880 -340 {
lab=Va}
N 900 -590 900 -540 {
lab=vgate}
N 890 -680 1130 -680 {
lab=VDD}
N 1330 -590 1570 -590 {
lab=vgate}
N 790 -20 1030 -20 {
lab=GND}
N 1260 -20 1520 -20 {
lab=GND}
N 780 -470 840 -470 {
lab=GND}
N 980 -470 1020 -470 {
lab=VDD}
N 980 -440 1000 -440 {
lab=VDD}
N 1000 -470 1000 -440 {
lab=VDD}
N 2450 -110 2450 -70 {
lab=#net7}
N 2370 -110 2450 -110 {
lab=#net7}
N 2370 -290 2370 -230 {
lab=#net7}
N 2370 -230 2370 -130 {
lab=#net7}
N 1390 -510 1420 -510 {
lab=GND}
N 1390 -510 1390 -410 {
lab=GND}
N 1390 -410 1460 -410 {
lab=GND}
C {devices/vsource.sym} 2730 -670 0 0 {name=V1 net_name=true value="'VDD' pwl 0us 0 5us 'VDD'"}
C {devices/vdd.sym} 2730 -700 0 0 {name=l8 lab=VDD}
C {devices/gnd.sym} 2730 -640 0 0 {name=l9 lab=GND}
C {sky130_fd_pr/pnp_05v5.sym} 690 -80 0 1 {name=Q2
model=pnp_05v5_W3p40L3p40
spiceprefix=X
}
C {devices/gnd.sym} 700 -20 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 740 -340 3 0 {name=l5 lab=Va}
C {devices/lab_pin.sym} 1020 -340 3 0 {name=l6 lab=Vb}
C {devices/vdd.sym} 820 -680 0 0 {name=l7 lab=VDD}
C {devices/ammeter.sym} 1260 -290 0 0 {name=Vr4 current=5.7238e-06}
C {devices/ammeter.sym} 1130 -290 0 0 {name=Vr2 current=4.3334e-06}
C {devices/ammeter.sym} 670 -460 0 0 {name=Vm1 current=1.0057e-05}
C {devices/ammeter.sym} 1130 -450 0 0 {name=Vm2 current=1.0057e-05}
C {devices/ammeter.sym} 1640 -500 0 0 {name=Vm3 current=1.0239e-05}
C {devices/ammeter.sym} 540 -290 0 0 {name=Vr1 current=5.7228e-06}
C {devices/ammeter.sym} 670 -290 0 0 {name=Vq2 current=4.3346e-06}
C {sky130_fd_pr/pnp_05v5.sym} 1150 -80 0 1 {name=Q1
model="pnp_05v5_W3p40L3p40 m=39"
spiceprefix=X
}
C {devices/lab_pin.sym} 1130 -150 0 0 {name=l4 lab=vbneg}
C {devices/lab_pin.sym} 670 -230 2 0 {name=l10 lab=Veb}
C {devices/lab_wire.sym} 820 -590 0 0 {name=l11 lab=vgate}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 180 -50 0 1 {name=M6
L=2
W=1
nf=1
mult=3.65
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 370 -360 1 0 {name=l12 lab=Vx}
C {devices/lab_pin.sym} 160 -110 0 0 {name=l18 lab=Vq}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 350 -50 0 0 {name=M7
L=2
W=1
nf=1
mult=3.65
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 350 -580 0 0 {name=M13
L=2
W=1
nf=1
mult=77.32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -580 0 0 {name=M1
L=2
W=1
nf=1
mult=386.6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1110 -580 0 0 {name=M2
L=2
W=1
nf=1
mult=386.6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1620 -590 0 0 {name=M3
L=2
W=1
nf=1
mult=386.6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 540 -210 0 0 {name=R1
W=0.35
L=21.839
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1260 -210 0 0 {name=R2
W=0.35
L=21.839
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1130 -210 0 0 {name=R3
W=0.35
L=3.763
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1640 -310 0 0 {name=R4
W=0.35
L=17.38
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/lab_pin.sym} 1640 -390 0 1 {name=l3 lab=vbg}
C {devices/code_shown.sym} 3030 -610 0 0 {name=s1 
only_toplevel=true 
spice_ignore=true

value="
.option savecurrents
.param R3val='22.187k'
.param alpha='1'
.param R2R3ratio='5.6555038*alpha'
.param R2val='R3val*R2R3ratio'
.param R4R2ratio='0.79694273'
.param R4val='R2val*R4R2ratio
.nodeset v(vgate)=1.4

.control
save all
+ @m.xm1.msky130_fd_pr__pfet_01v8_lvt[gm]
+ @m.xm2.msky130_fd_pr__pfet_01v8_lvt[gm]
+ @m.xm3.msky130_fd_pr__pfet_01v8_lvt[gm]
+ @m.xm4.msky130_fd_pr__pfet_01v8_lvt[gm]
+ @m.xm5.msky130_fd_pr__nfet_01v8_lvt[gm]
+ @m.xm6.msky130_fd_pr__nfet_01v8_lvt[gm]
+ @m.xm7.msky130_fd_pr__nfet_01v8_lvt[gm]
+ @m.xm8.msky130_fd_pr__pfet_01v8_lvt[gm]
+ @m.xm9.msky130_fd_pr__nfet_01v8_lvt[gm]
+ @m.xm13.msky130_fd_pr__pfet_01v8_lvt[gm]

op
write tsmc_bandgap_real.raw
let id8=@m.xm8.msky130_fd_pr__pfet_01v8_lvt[id]
let id1=@m.xm1.msky130_fd_pr__pfet_01v8_lvt[id]
let vth5=@m.xm5.msky130_fd_pr__nfet_01v8_lvt[vth]
let vth6=@m.xm6.msky130_fd_pr__nfet_01v8_lvt[vth]
let wm8=@m.xm8.msky130_fd_pr__pfet_01v8_lvt[w]
let mm8=@m.xm8.msky130_fd_pr__pfet_01v8_lvt[m]
let weff8=wm8*mm8
let jd8=id8/weff8
let wm1=@m.xm1.msky130_fd_pr__pfet_01v8_lvt[w]
let mm1=@m.xm1.msky130_fd_pr__pfet_01v8_lvt[m]
let weff1=wm1*mm1
let jd1=id1/weff1
let wm13=@m.xm13.msky130_fd_pr__pfet_01v8_lvt[w]
let mm13=@m.xm13.msky130_fd_pr__pfet_01v8_lvt[m]
let weff13=wm13*mm13
let id13=@m.xm13.msky130_fd_pr__pfet_01v8_lvt[id]
let jd13=id13/weff13
let gm13=@m.xm13.msky130_fd_pr__pfet_01v8_lvt[gm]
let gm3=@m.xm3.msky130_fd_pr__pfet_01v8_lvt[gm]
let gm4=@m.xm4.msky130_fd_pr__pfet_01v8_lvt[gm]
let gm5=@m.xm5.msky130_fd_pr__nfet_01v8_lvt[gm]
let gm6=@m.xm6.msky130_fd_pr__nfet_01v8_lvt[gm]
let gm7=@m.xm7.msky130_fd_pr__nfet_01v8_lvt[gm]
let gm8=@m.xm8.msky130_fd_pr__pfet_01v8_lvt[gm]
let gm9=@m.xm9.msky130_fd_pr__nfet_01v8_lvt[gm]
let gm1=@m.xm1.msky130_fd_pr__pfet_01v8_lvt[gm]
let gm2=@m.xm2.msky130_fd_pr__pfet_01v8_lvt[gm]
let vdsat1=2/(gm1/vm1#branch)
let vdsat2=2/(gm2/vm2#branch)
let vdsat3=2/(gm3/vm3#branch)
let vdsat4=2/(gm4/@m.xm4.msky130_fd_pr__pfet_01v8_lvt[id])
let vdsat5=2/(gm5/@m.xm5.msky130_fd_pr__nfet_01v8_lvt[id])
let vdsat6=2/(gm6/@m.xm6.msky130_fd_pr__nfet_01v8_lvt[id])
let vdsat7=2/(gm7/@m.xm7.msky130_fd_pr__nfet_01v8_lvt[id])
let vdsat8=2/(gm8/@m.xm8.msky130_fd_pr__pfet_01v8_lvt[id])
let vdsat9=2/(gm9/@m.xm9.msky130_fd_pr__nfet_01v8_lvt[id])
let vdsat13=2/(gm13/@m.xm13.msky130_fd_pr__pfet_01v8_lvt[id])


print vbg vgate vg va vb vx vq
print vdsat1 vdsat2 vdsat3 vdsat4 
+ vdsat5 vdsat6 vdsat7 vdsat8 vdsat9 vdsat13 
.endc
"}
C {devices/launcher.sym} 3100 -680 0 0 {name=h1
descr=Annotate 
tclcommand="ngspice::annotate"}
C {devices/ngspice_probe.sym} 670 -340 0 0 {name=r1}
C {devices/ngspice_probe.sym} 1130 -340 0 0 {name=r2}
C {devices/ngspice_probe.sym} 370 -330 0 0 {name=r3}
C {devices/ngspice_probe.sym} 820 -590 0 0 {name=r5}
C {devices/ngspice_probe.sym} 1640 -360 0 0 {name=r8}
C {devices/ngspice_probe.sym} 1130 -150 0 0 {name=r9}
C {devices/ngspice_get_value.sym} 370 -450 0 0 {name=r16 node=i(@m.xm13.msky130_fd_pr__pfet_01v8_lvt[id])
descr="I="}
C {devices/ngspice_get_value.sym} 390 -510 0 0 {name=r14 node=@m.xm13.msky130_fd_pr__pfet_01v8_lvt[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 690 -510 0 0 {name=r20 node=@m.xm1.msky130_fd_pr__pfet_01v8_lvt[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 1100 -510 0 1 {name=r21 node=@m.xm2.msky130_fd_pr__pfet_01v8_lvt[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 1650 -540 0 0 {name=r22 node=@m.xm3.msky130_fd_pr__pfet_01v8_lvt[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 180 -80 0 0 {name=r15 node=@m.xm6.msky130_fd_pr__nfet_01v8_lvt[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 350 -80 0 1 {name=r23 node=@m.xm7.msky130_fd_pr__nfet_01v8_lvt[gm]
descr="gm="}
C {devices/launcher.sym} 3100 -720 0 0 {name=h2
descr="View Raw file" 
tclcommand="textwindow $netlist_dir/[file tail [file rootname [ xschem get schname 0 ] ] ].raw"
}
C {devices/code_shown.sym} -580 -690 0 0 {name=NGSPICE
only_toplevel=true
spice_ignore=false
value="
.option savecurrents
.option warn=1
.param VDD=1.8
.param R3val='22.187k'
.param alpha='1'
.param R2R3ratio='5.6555038*alpha'
.param R2val='R3val*R2R3ratio' 
.param R4R2ratio=0.79694273
.param R4val='R2val*R4R2ratio'
.nodeset v(vgate)=1.3
.option temp=0
.dc temp -10 80 10m
.control
save all
*+ @m.xm13.msky130_fd_pr__pfet_01v8_lvt[gm]
*+ @m.xm3.msky130_fd_pr__pfet_01v8_lvt[gm]
*+ @m.xm4.msky130_fd_pr__pfet_01v8_lvt[gm]
*+ @m.xm5.msky130_fd_pr__nfet_01v8_lvt[gm]
*+ @m.xm6.msky130_fd_pr__nfet_01v8_lvt[gm]
*+ @m.xm7.msky130_fd_pr__nfet_01v8_lvt[gm]
*+ @m.xm8.msky130_fd_pr__pfet_01v8_lvt[gm]
*+ @m.xm9.msky130_fd_pr__nfet_01v8_lvt[gm]
run
plot Vbg
plot deriv(Vbg)
plot vbg vfeedback vcurrent_gate
let iout = vm3#branch
let iref = vm4#branch
let iref_final = vm5#branch
plot iout iref iref_final
plot iref iref_final
plot deriv(iout) deriv(iref) deriv(iref_final)
plot vcurrent_gate vd5 vd4
save vbg deriv(vbg)
let i_left = vm1#branch
let i_right = vm2#branch
plot i_left i_right
plot va vb
let i = vm3#branch
let indx27 = 3700
let indx0 = 1000
let indx70 = 8000
*indx is the index of temperature sweep for 27degC
echo 'Vbg @ 27degC'
let vbg27c = vbg[indx27]
print vbg27c
echo 'dVbe/degC & ppm @ 27degC'
print deriv(vbg)[indx27] deriv(vbg)[indx27]/vbg27c
echo 'ppm real'
print (vbg[indx70]-vbg[indx0])/vbg[indx27]/(70-0)*1e6
*plot deriv(vbg)/vbg27c
*plot v(va, vb) vs i
*plot vm1#branch vm2#branch vm3#branch
save deriv(vbg)/vbg27c
let vsg = vdd - vgate
let vsd1 = vdd - va
let vsd2 = vdd - vb
let vsd3 = vdd - vbg
*let vthp = @m.xm1.msky130_fd_pr__pfet_01v8_lvt['vth']
*let vov = vsg - vthp
**plot vov vsd1 vsd2 vsd3
*let deltav = vb - vbneg
*let r4 =vbg/vm3#branch
*let r1 =va/vr1#branch
*let r2 =vb/vr4#branch
*let r3 =deltav/vr2#branch
*let vptat =(r2/r3*deltav)
*let sum = veb+vptat
**plot veb vptat sum
**plot deriv(veb) deriv(vptat)
*save veb vptat sum deriv(veb) deriv(vptat)
*let gm1=@m.xm1.msky130_fd_pr__pfet_01v8_lvt[gm]
*let gm2=@m.xm2.msky130_fd_pr__pfet_01v8_lvt[gm]
*let Av2=gm2 * ((r3 + r3/ln(39)) * r2 / (r3 + r3/ln(39) + r2) )
*let Av1=gm1 * (r1 * r3/ln(39))/(r1 + r3/ln(39))
**plot Av1 Av2 Av2/Av1
*let gm13=@m.xm13.msky130_fd_pr__pfet_01v8_lvt[gm]
*let gm3=@m.xm3.msky130_fd_pr__pfet_01v8_lvt[gm]
*let gm4=@m.xm4.msky130_fd_pr__pfet_01v8_lvt[gm]
*let gm5=@m.xm5.msky130_fd_pr__nfet_01v8_lvt[gm]
*let gm6=@m.xm6.msky130_fd_pr__nfet_01v8_lvt[gm]
*let gm7=@m.xm7.msky130_fd_pr__nfet_01v8_lvt[gm]
*let gm8=@m.xm8.msky130_fd_pr__pfet_01v8_lvt[gm]
*let gm9=@m.xm9.msky130_fd_pr__nfet_01v8_lvt[gm]
*let vdsat1=2/(gm1/vm1#branch)
*let vdsat2=2/(gm2/vm2#branch)
*let vdsat3=2/(gm3/vm3#branch)
*let vdsat4=2/(gm4/@m.xm4.msky130_fd_pr__pfet_01v8_lvt[id])
*let vdsat5=2/(gm5/@m.xm5.msky130_fd_pr__nfet_01v8_lvt[id])
*let vdsat6=2/(gm6/@m.xm6.msky130_fd_pr__nfet_01v8_lvt[id])
*let vdsat7=2/(gm7/@m.xm7.msky130_fd_pr__nfet_01v8_lvt[id])
*let vdsat8=2/(gm8/@m.xm8.msky130_fd_pr__pfet_01v8_lvt[id])
*let vdsat9=2/(gm9/@m.xm9.msky130_fd_pr__nfet_01v8_lvt[id])
*let vdsat13=2/(gm13/@m.xm13.msky130_fd_pr__pfet_01v8_lvt[id])
*save (vdd-va-vdsat1) (vdd-vb-vdsat2) (vdd-vbg-vdsat3)
*+ (vdd-vgate-vdsat4) (vgate-vq-vdsat5) (vq-0-vdsat6)
*+ (vx-0-vdsat7) (vdd-vg-vdsat8) (vg-vq-vdsat9) (vdd-vx-vdsat13)

unset askquit
*quit
.endc
" }
C {devices/gnd.sym} 240 -20 0 0 {name=l17 lab=GND}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1440 -510 0 0 {name=M10
L='2'
W='1'
nf=1
mult=34
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/vsource.sym} 2730 -540 0 0 {name=V2 net_name=true value="0 pulse(0V 1.8V 10us 0us 0us 5us)"}
C {devices/gnd.sym} 2730 -510 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} 2730 -570 0 0 {name=l19 lab=porst}
C {devices/capa.sym} 1370 -630 0 0 {name=C1
m=1
value=20p
footprint=1206
device="ceramic capacitor"}
C {devices/capa.sym} 460 -280 0 0 {name=C2
m=1
value=20p
footprint=1206
device="ceramic capacitor"}
C {devices/code_shown.sym} 3570 -620 0 0 {name=s2 
only_toplevel=true 
spice_ignore=true

value="
.option savecurrents
.param R3val='22.187k'
.param alpha='1'
.param R2R3ratio='5.6555038*alpha'
.param R2val='R3val*R2R3ratio'
.param R4R2ratio='0.79694273'
.param R4val='R2val*R4R2ratio
.control
save all
+ @m.xm1.msky130_fd_pr__pfet_01v8_lvt[gm]
+ @m.xm2.msky130_fd_pr__pfet_01v8_lvt[gm]
+ @m.xm3.msky130_fd_pr__pfet_01v8_lvt[gm]
+ @m.xm4.msky130_fd_pr__pfet_01v8_lvt[gm]
+ @m.xm5.msky130_fd_pr__nfet_01v8_lvt[gm]
+ @m.xm6.msky130_fd_pr__nfet_01v8_lvt[gm]
+ @m.xm7.msky130_fd_pr__nfet_01v8_lvt[gm]
+ @m.xm8.msky130_fd_pr__pfet_01v8_lvt[gm]
+ @m.xm9.msky130_fd_pr__nfet_01v8_lvt[gm]
+ @m.xm13.msky130_fd_pr__pfet_01v8_lvt[gm]

option temp=27
tran 0.1n 20u
option temp=0
tran 0.1n 20u
option temp=70
tran 0.1n 20u
write tsmc_bandgap_real_70degc_vbg.raw vbg
setplot tran2
write tsmc_bandgap_real_0degc_vbg.raw vbg
setplot tran1
write tsmc_bandgap_real_27degc_vbg.raw vbg
.endc
"}
C {devices/code.sym} 540 90 0 0 {name=NGSPICE1
only_toplevel=true
spice_ignore=true
value=".option seed=13

* this experimental option enables mos model bin 
* selection based on W/NF instead of W
.param ABSVAR=0.03
.param VDDGAUSS=agauss(1.8, 'ABSVAR', 1)
.param VDD=VCCGAUSS
** variation parameters:
.param sky130_fd_pr__nfet_01v8_lvt__vth0_slope_spectre='agauss(0, ABSVAR, 3)/sky130_fd_pr__nfet_01v8_lvt__vth0_slope'
.param sky130_fd_pr__pfet_01v8_lvt__vth0_slope_spectre='agauss(0, ABSVAR, 3)/sky130_fd_pr__pfet_01v8_lvt__vth0_slope'
.param sky130_fd_pr__nfet_01v8__vth0_slope_spectre='agauss(0, ABSVAR, 3)/sky130_fd_pr__nfet_01v8__vth0_slope'
.param sky130_fd_pr__pfet_01v8__vth0_slope_spectre='agauss(0, ABSVAR, 3)/sky130_fd_pr__pfet_01v8__vth0_slope'

.param sky130_fd_pr__pfet_01v8__toxe_slope_spectre='agauss(0, ABSVAR*2, 3)/sky130_fd_pr__pfet_01v8__toxe_slope'
.param sky130_fd_pr__nfet_01v8__toxe_slope_spectre='agauss(0, ABSVAR*2, 3)/sky130_fd_pr__nfet_01v8__toxe_slope'
.param sky130_fd_pr__pfet_01v8_lvt__toxe_slope_spectre='agauss(0, ABSVAR*2, 3)/sky130_fd_pr__pfet_01v8_lvt__toxe_slope'
.param sky130_fd_pr__nfet_01v8_lvt__toxe_slope_spectre='agauss(0, ABSVAR*2, 3)/sky130_fd_pr__nfet_01v8_lvt__toxe_slope'

.param sky130_fd_pr__res_high_po__var_mult=agauss(0, 'ABSVAR*8', 1)

* .options savecurrents
.control
  let run=1
  dowhile run <= 40
    if run > 1
      reset
      set appendwrite
    end
    save all
    if run % 3 = 0
      set temp=0
    end
    if run % 3 = 1
      set temp=27
    end
    if run % 3 = 2
      set temp=70
    end
    tran 0.05u 150u
    write tsmc_bandgap_real_variation.raw
    let run = run + 1
  end
  set nolegend
  plot all.vbg
.endc
" }
C {devices/code.sym} -720 -150 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2170 -480 0 0 {name=M11
L=2
W=2
nf=1
mult=40
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/gnd.sym} 1970 -330 0 0 {name=l13 lab=GND}
C {devices/ammeter.sym} 2190 -350 0 0 {name=Vm4 current=1.0239e-05}
C {design/opamp/opamp.sym} 1970 -430 0 0 {name=x1}
C {devices/lab_pin.sym} 1810 -320 0 1 {name=l20 lab=vfeedback}
C {devices/lab_pin.sym} 2100 -430 1 0 {name=l21 lab=vcurrent_gate}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2350 -480 0 0 {name=M12
L=2
W=2
nf=1
mult=40
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/ammeter.sym} 2370 -350 0 0 {name=Vm5 current=1.0239e-05}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 2390 -70 0 1 {name=M4
L=2
W=8
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {res.sym} 2190 -180 0 0 {name=R5
value=42k
footprint=1206
device=resistor
m=1}
C {design/opamp/opamp.sym} 900 -470 1 1 {name=x2}
C {devices/gnd.sym} 780 -470 0 0 {name=l2 lab=GND}
C {devices/lab_wire.sym} 1020 -470 0 1 {name=l14 lab=VDD}
C {devices/lab_pin.sym} 2370 -420 0 1 {name=l24 lab=vd5}
C {devices/lab_pin.sym} 2190 -410 0 1 {name=l25 lab=vd4}
